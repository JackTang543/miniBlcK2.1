# Keil uVision project f411ceu6_sig.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: STM32F411CEUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: f411ceu6_sig +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=8 v6Lto=1 wLevel=3
  c define: USE_HAL_DRIVER,STM32F411xE,ARM_MATH_CM4
  c include: ..\sAPP;..\sBSP;..\sDRV;..\sHMI;..\sMID;..\sUSER;..\HAL\STM32F4xx_HAL_Driver\Inc;..\HAL\CMSIS\Device\ST\STM32F4xx\Include;..\HAL\STM32F4xx_HAL_Driver\Inc\Legacy;..\HAL\CMSIS\DSP\Include;..\HAL\CMSIS\Include;..\sMID\FreeRTOS\include;..\sMID\FreeRTOS\portable\MemMang;..\sMID\FreeRTOS;..\sMID\FreeRTOS\portable\GCC;..\sMID\FreeRTOS-Plus-CLI;..\sMID\cot_menu;..\sMID\sGenBtnDrv2;..\sMID\sGraphic2D
  asm include: ..\sUSER
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group sUSER
    ../sUSER/: stm32f4xx_it.c stm32f4xx_hal_msp.c system_stm32f4xx.c startup_stm32f411xe.s stm32f4xx_hal_conf.h stm32f4xx_it.h main.h main.c
    ../HAL/CMSIS/Lib/ARM/: arm_cortexM4lf_math.lib
  group sAPP
    ../sAPP/: sAPP_AHRS.c sAPP_Func.c sAPP_Task.c sAPP_10DoF.c sAPP_FILTER.c sAPP_Math.c sAPP_CTRL.c sAPP_Motor.c sAPP_CLI.c
  group sDRV
    ../sDRV/: sDRV_MPU6050.c sDRV_HMC5883L.c sDRV_BMP280.c sDRV_RTC.c sDRV_MB85RCxx.c sDRV_GMR.c sDRV_DRV8870.c sDRV_INA219.c sDRV_NTC.c sDRV_PwrLED.c sDRV_WS2812.c
  group sHMI
    ../sHMI/: sHMI_Debug.c sHMI_LED.c sHMI_BUZZER.c sHMI_G75.c
  group sBSP
    ../sBSP/: sBSP_GPIO.c sBSP_RCC .c sBSP_UART.c sBSP_softI2C.c sBSP_TIMEBASE.c sBSP_SYS.c sBSP_SPI.c sBSP_TIM.c sBSP_RTC.c sBSP_F4_I2C.c sBSP_DWT.c sBSP_DMA.c
  group HAL
    ../HAL/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_can.c stm32f4xx_hal_cec.c stm32f4xx_hal_cortex.c stm32f4xx_hal_crc.c stm32f4xx_hal_cryp.c stm32f4xx_hal_cryp_ex.c stm32f4xx_hal_dac.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_dcmi.c stm32f4xx_hal_dcmi_ex.c stm32f4xx_hal_dfsdm.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_dsi.c stm32f4xx_hal_eth.c stm32f4xx_hal_exti.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_fmpi2c.c stm32f4xx_hal_fmpi2c_ex.c stm32f4xx_hal_fmpsmbus.c stm32f4xx_hal_fmpsmbus_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_hash.c stm32f4xx_hal_hash_ex.c stm32f4xx_hal_hcd.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_i2s.c stm32f4xx_hal_i2s_ex.c stm32f4xx_hal_irda.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_lptim.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_ltdc_ex.c stm32f4xx_hal_mmc.c stm32f4xx_hal_nand.c stm32f4xx_hal_nor.c stm32f4xx_hal_pccard.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_qspi.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rng.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_sai.c stm32f4xx_hal_sai_ex.c stm32f4xx_hal_sd.c stm32f4xx_hal_sdram.c stm32f4xx_hal_smartcard.c stm32f4xx_hal_smbus.c stm32f4xx_hal_spdifrx.c stm32f4xx_hal_spi.c stm32f4xx_hal_sram.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_hal_wwdg.c
  group sMID/FreeRTOS/src
    ../sMID/FreeRTOS/src/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group sMID/FreeRTOS/inc
    ../sMID/FreeRTOS/include/: atomic.h croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stream_buffer.h task.h timers.h
  group sMID/FreeRTOS/port
    ../sMID/FreeRTOS/: FreeRTOSConfig.h
    ../sMID/FreeRTOS/portable/GCC/: port.c
    ../sMID/FreeRTOS/portable/MemMang/: heap_4.c
  group sMID/FreeRTOS-Plus-CLI
    ../sMID/FreeRTOS-Plus-CLI/: FreeRTOS_CLI.c
  group sMID/sGraphic2D
    ../sMID/sGraphic2D/: sAPP_Font.c sDRV_GenOLED.c sGraphic2D.c
  group sMID/sGenBtnDrv2
    ../sMID/sGenBtnDrv2/: sGenBtnDrv2.c
  group sMID/cot_menu
    ../sMID/cot_menu/: cot_menu.c
